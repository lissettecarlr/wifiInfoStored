# Keil uVision project demo.uvprojx, settings and files
target template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: demo
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\..\..\lib\math;..\..\..\lib\onchip\delay;..\..\..\lib\onchip\flash;..\..\..\lib\onchip\GPIO;..\..\..\lib\onchip\interrupt;..\..\..\lib\onchip\taskManager;..\..\..\lib\onchip\USART;.\app;..\..\..\WIFI_Memory
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group lib/onchip
    ../../../lib/onchip/delay/: Delay.cpp
    ../../../lib/onchip/flash/: Flash.cpp
    ../../../lib/onchip/GPIO/: GPIO.cpp
    ../../../lib/onchip/interrupt/: Interrupt.cpp
    ../../../lib/onchip/taskManager/: TaskManager.cpp
    ../../../lib/onchip/USART/: USART.cpp
  group app
    ./app/: Main.cpp Configuration.h UserInterrupt.cpp transmission.cpp transmission.h
    ../../../WIFI_Memory/: WIFI_Memory.cpp WIFI_Memory.h
software components: CMSIS:CORE 4.3.0, Device:GPIO 1.2, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:EXTI 3.5.0, Device:StdPeriph Drivers:Flash 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
